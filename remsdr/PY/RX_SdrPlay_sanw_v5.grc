options:
  parameters:
    author: F1ATB - BUHART
    copyright: GNU General Public Licence v3.0
    description: RX for SDR-PLAY RSP1, RSP1A
    generate_options: no_gui
    id: RX_SdrPlay_sanw_v5
    output_language: python
    run_options: run
    title: SdrPlay SSB AM NBFN WBFM  Receiver V5- F1ATB - APRIL 2022
  states: {}

blocks:
- name: Ffine
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Fsdr
  id: variable
  parameters:
    value: '145000000'
  states: {}
- name: G1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: G2
  id: variable
  parameters:
    value: '-20'
  states: {}
- name: G3
  id: variable
  parameters:
    value: '20'
  states: {}
- name: LSB_USB
  id: variable
  parameters:
    value: min(1,Modulation)
  states: {}
- name: Largeur_filtre_AM
  id: variable
  parameters:
    value: '7500'
  states: {}
- name: Largeur_filtre_NBFM
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: Largeur_filtre_SSB
  id: variable
  parameters:
    value: '3800'
  states: {}
- name: Largeur_filtre_WBFM
  id: variable
  parameters:
    value: '150000'
  states: {}
- name: ModulSelect
  id: variable
  parameters:
    value: max(0,Modulation -1)
  states: {}
- name: Modulation
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Squelch
  id: variable
  parameters:
    value: '-80'
  states: {}
- name: decim_LP
  id: variable
  parameters:
    value: '27'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: SampRate
  states: {}
- name: xlate_filter_taps_AM
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, Largeur_filtre_AM/2, 1500)
  states: {}
- name: xlate_filter_taps_NBFM
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, Largeur_filtre_NBFM/2, 2000)
  states: {}
- name: xlate_filter_taps_SSB
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, Largeur_filtre_SSB/2, 760)
  states: {}
- name: xlate_filter_taps_WBFM
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, Largeur_filtre_WBFM/2, 25000)
  states: {}
- name: SampRate
  id: parameter
  parameters:
    type: eng_float
    value: '3000000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    max_gain: '100'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '20000'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '10000'
    max_dev: 5e3
    quad_rate: '40000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Largeur_filtre_SSB/2+100
    offset: '0'
    phase: '0'
    samp_rate: '10000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_simple_squelch_cc_0_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '20'
    quad_rate: '200000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16000'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '100'
    vlen: '2048'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: int(2048*decim_LP)
    n: 2048*int(samp_rate/10000)
    offset: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-2*LSB_USB
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: ModulSelect
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: ModulSelect
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: device
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: Ffine-Largeur_filtre_SSB/2+LSB_USB*Largeur_filtre_SSB-100+LSB_USB*200
    decim: int(samp_rate/10000)
    samp_rate: samp_rate
    taps: xlate_filter_taps_SSB
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: Ffine
    decim: int(samp_rate/40000)
    samp_rate: samp_rate
    taps: xlate_filter_taps_NBFM
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: Ffine
    decim: int(samp_rate/10000)
    samp_rate: samp_rate
    taps: xlate_filter_taps_AM
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: Ffine
    decim: int(samp_rate/200000)
    samp_rate: samp_rate
    taps: xlate_filter_taps_WBFM
    type: ccc
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '2048'
    frame_rate: 10000/2048
    ref_scale: '0.0000000001'
    sample_rate: '10000'
    shift: 'False'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4333'
    decim: '1'
    gain: '1'
    samp_rate: decim_LP*10000
    type: fir_filter_ccf
    width: '1200'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: decim_LP
    type: complex
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '9002'
    type: short
    vlen: '2048'
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '9001'
    type: short
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    agc: G1
    bandwidth: '5000000'
    center_freq: Fsdr
    gain: G2
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '9003'
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_agc_xx_0, '0', analog_simple_squelch_cc_0_0, '0']
- [analog_nbfm_rx_0, '0', blocks_selector_1, '2']
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', blocks_complex_to_mag_0, '0']
- [analog_simple_squelch_cc_0_1, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_selector_1, '3']
- [blocks_add_xx_0, '0', blocks_selector_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_selector_1, '1']
- [blocks_float_to_short_0, '0', network_tcp_sink_0_0, '0']
- [blocks_float_to_short_1, '0', network_tcp_sink_0, '0']
- [blocks_keep_m_in_n_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_selector_0, '1', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_selector_0, '2', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_selector_0, '3', freq_xlating_fir_filter_xxx_0_2, '0']
- [blocks_selector_1, '0', blocks_float_to_short_0, '0']
- [dc_blocker_xx_0, '0', blocks_keep_m_in_n_0, '0']
- [dc_blocker_xx_0, '0', blocks_selector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_2, '0', analog_simple_squelch_cc_0_1, '0']
- [logpwrfft_x_0, '0', blocks_float_to_short_1, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', logpwrfft_x_0, '0']
- [soapy_sdrplay_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.5.0-62-gf520c346
