options:
  parameters:
    author: F1ATB - BUHART
    copyright: GNU General Public Licence v3.0
    description: TX SSB NBFM HackRf One
    generate_options: no_gui
    id: TX_Hack_ssbnbfm_v5
    output_language: python
    run_options: run
    title: SSB NBFM Transmitter V5 - F1ATB - APRIL 2022
  states: {}

blocks:
- name: Fsdr
  id: variable
  parameters:
    value: '432100000'
  states: {}
- name: G1
  id: variable
  parameters:
    value: '14'
  states: {}
- name: G2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LNUC
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: SampRate
  states: {}
- name: SampRate
  id: parameter
  parameters:
    type: eng_float
    value: '2000000'
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '10000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(samp_rate/20)
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1300+LNUC*1500
    low_cutoff_freq: '-1300+LNUC*1500'
    samp_rate: '10000'
    type: fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: '10000'
    type: fir_filter_fff
    width: '1200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: LNUC
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: abs(LNUC)
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: abs(LNUC)
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: device
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '10'
    minoutbuf: '10'
    num_taps: '64'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '128'
    port: '9005'
    src_zeros: 'False'
    type: short
  states: {}
- name: note_0
  id: note
  parameters:
    note: CW
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: SSB
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/10000)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/10000)
    taps: ''
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: G1
    center_freq: Fsdr
    dev_args: device
    samp_rate: samp_rate
    type: fc32
    vga: G2
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '9004'
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_float_to_complex_0_0, '1']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_1_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [band_pass_filter_0_0, '0', analog_nbfm_tx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0_0, '0', rational_resampler_xxx_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_selector_0, '0', band_pass_filter_0_0, '0']
- [blocks_selector_0, '1', hilbert_fc_0, '0']
- [blocks_selector_0, '2', blocks_float_to_complex_0_0, '0']
- [blocks_selector_1, '0', soapy_hackrf_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_selector_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [network_udp_source_0, '0', blocks_short_to_float_0, '0']
- [rational_resampler_xxx_1, '0', blocks_selector_1, '1']
- [rational_resampler_xxx_1_0, '0', blocks_selector_1, '0']
- [rational_resampler_xxx_1_1, '0', blocks_selector_1, '2']

metadata:
  file_format: 1
  grc_version: v3.9.5.0-62-gf520c346
