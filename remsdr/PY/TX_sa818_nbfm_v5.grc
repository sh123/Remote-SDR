options:
  parameters:
    author: F1ATB - BUHART
    copyright: GNU General Public Licence v3.0
    description: TX NBFM Audio SDR = SA818
    generate_options: no_gui
    id: TX_sa818_nbfm_v5
    output_language: python
    run_options: run
    title: NBFM Transmitter V5 - F1ATB - MAY 2022
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:0,0
    samp_rate: samp_rate
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '128'
    port: '9005'
    src_zeros: 'False'
    type: short
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '16'
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [network_udp_source_0, '0', blocks_short_to_float_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.5.0-62-gf520c346
